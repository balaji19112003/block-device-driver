## yocto-block/meta-myblock/conf/layer.conf
```bitbake
# Yocto Layer
BBPATH .= ":${LAYERDIR}"
BBFILES += "${LAYERDIR}/recipes-myblock/*/*.bb"
```
